# bbappend para agregar ffmpeg y soporte de cámara a la imagen base
IMAGE_INSTALL += "ffmpeg v4l-utils"
